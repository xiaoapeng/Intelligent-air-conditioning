# Keil uVision project demoPro.uvprojx, settings and files
target demo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: demoPro +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\apps;..\drivers\inc;..\libraries\CMSIS\CM3\CoreSupport;..\libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\libraries\STM32F10x_StdPeriph_Driver\inc;..\Utils;..\Gizwits;..\TEXT;..\USMART;..\FATFS\exfuns;..\FATFS\src;..\FATFS\src\option;..\PICTURE;..\MALLOC;..\GAME
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group apps
    ../apps/: main.c stm32f10x_it.c init.c transplant.c
  group drivers
    ../drivers/src/: drv_cmd.c drv_delay.c drv_key.c drv_led.c drv_sleep.c drv_button.c drv_basetim6.c drv_time3.c drv_dma.c drv_adc.c DataScope_DP.C drv_iic.c drv_at24cxx.c drv_usart.c drv_lcd.c w25qxx.c spi.c sdio_sdcard.c drv_remote.c drv_ht11.c drv_lsens.c drv_joypad.c
  group cmsis
    ../libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group startup
    ../libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group stdLib
    ../libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group include
    ../drivers/inc/: drv_basetim6.h drv_button.h drv_cmd.h drv_delay.h drv_key.h drv_led.h drv_sleep.h drv_time3.h drv_usart1.h
  group Utils
    ../Utils/: common.c dataPointTools.c ringbuffer.c
  group Gizwits
    ../Gizwits/: gizwits_product.c gizwits_protocol.c
  group text
    ../TEXT/: fontupd.c text.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group PICTURE
    ../PICTURE/: bmp.c gif.c piclib.c tjpgd.c
  group MALLOC
    ../MALLOC/: malloc.c
  group FATFS
    ../FATFS/src/: ff.c diskio.c
    ../FATFS/src/option/: mycc936.c
    ../FATFS/exfuns/: exfuns.c fattester.c
  group GAME
    ../GAME/: Gluttonous_Snake_key.c Gluttonous_Snake.c
